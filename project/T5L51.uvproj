# Keil uVision project T5L51.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: 1.bat
  c flags: Optimize=8 SizeSpeed=1
  c define: _RX_TEST _USE_POLL _JPGTEST
  c include: ..\include;..\source;..\user;..\modules;..\project;..\include\T5L
  asm include: ..\include;..\source;..\user;..\modules;..\modules;..\project;..\include\T5L
  link misc: REMOVEUNUSED
  group include
    ./: STARTUP_M5.A51
    ../include/: sys.c sys.h
    ../include/T5L/: t5los8051.h T5LOSConfig.h
  group source
    ../source/: gpio.c gpio.h uart.c uart.h timer.c timer.h modbus.c modbus.h i2c.c i2c.h core_json.c core_json.h TA_protocal.c TA_protocal.h
  group user
    ../user/: main.c
  group modules
    ../modules/: rtc.c rtc.h r11_common.c r11_common.h r11_netskinAnalyze.c r11_netskinAnalyze.h r11_n5camera.c r11_n5camera.h r11_advertise.c r11_advertise.h suggestionsGB2312.h 4G_air780e.c 4G_air780e.h ota.c ota.h
